# IAR project STM32_PID.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; STM32F103xE
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\Drivers\CMSIS\Include; ..\HARDWARE\MPU6050\eMPL; ..\HARDWARE\MPU6050; ..\HARDWARE\sys; ..\HARDWARE\CAN
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_PID.srec
  ILINK.IlinkOutputFile: STM32_PID.out
  ILINK.IlinkIcfFile: E:\wk\PID\IAR_projekt\Drivers\CMSIS\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group HARDWARE/CAN
    ../HARDWARE/CAN/: can.c
  group HARDWARE/MPU6050
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
  group HARDWARE/MPU6050/eMPL
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group HARDWARE/sys
    ../HARDWARE/sys/: sys.c
  group Src
    ../Src/: delayus.c Encoder.c Loop.c main.c MotorControl.c pid.c ShareWare.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c tim2.c tim3.c tim4.c tim5.c tim8.c VelocityControl.c
